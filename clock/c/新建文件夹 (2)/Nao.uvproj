# Keil uVision project Nao.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Nao +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS18B20.c DS1302.c keyboard.c Lcd1602.c main.c Time.c
  group New Group
    ./: Time.h main.h Lcd1602.h keyboard.h DS1302.h DS18B20.h config.h
