# Keil uVision project nRF24l01.uvprojx, settings and files
target nRF24l01 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: nRF24l01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\HARDWARE;..\FLASH_EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Drv_periph
    ../HARDWARE/NRF24L01/: bsp_NRF24L01.c
    ../HARDWARE/usart/: bsp_debug_usart.c
  group eeprom
    ../FLASH_EEPROM/: app_eeprom.c stm_flash.c
    ../FLASH_EEPROM/e2prom/: emulation_ee.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_usart.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c gpio.c main.c stm32f1xx_it.c
software components: CMSIS:CORE 4.3.0
